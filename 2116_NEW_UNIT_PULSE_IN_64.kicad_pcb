# Repository longshowadenshi/-2116_WiringChallenge-

## KiCad design 2116_NEW_UNIT_PULSE_IN_64.kicad_pcb

Board: 2 copper layers, 166.0 x 180.0 mm, 168 parts (103 on the bottom side), 360 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40: 0.1uF; C_0603
C23: 470uF/10V; CP_D8_P3R5
CN1: 09031966921; cn_09031966921
CN2: 09232486824; cn_09282486801
CN3: B2B-XH-A; cn_B2B-XH-A
CN4, CN5, CN8, CN9: HIF3FC-16PA-2.54DS; cn_HIF3FC-16PA-254DS
CN6, CN7, CN10, CN11: HIF3FC-16PA-2.54DSA; cn_HIF3FC-16PA-254DSA
FL1: BNX002-01
IC1, IC23: 74HCT32; IC_DIP-14_W7.62mm
IC2: 74HCT138; ic_DIP-16_W7.62mm
IC3, IC4, IC5, IC6, IC7, IC8, IC13, IC14, IC15, IC16, IC17, IC18: 74HC14; IC_DIP-14_W7.62mm
IC9, IC10, IC11, IC12, IC19, IC20, IC21, IC22: 74HC244; ic_DIP-20_W7.62mm
IC24, IC25, IC26, IC27, IC32, IC33, IC34, IC35: 74HCT574; ic_DIP-20_W7.62mm
IC28, IC29, IC30, IC31, IC36, IC37, IC38, IC39: 74HCT541; ic_DIP-20_W7.62mm
LED1: GREEN; LED_D3.0mm_center
R1: 470; R_TH_5R08
R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65: 470; C_0603
RA1, RA2, RA3, RA4, RA5, RA6, RA7, RA8: 4.7K * 8; RKC1_8B8
TP1, TP2: ST-2-1; LC-2-G
TP3: LC-2-G

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, FL1.2, IC1.14, IC2.16, IC3.14, IC4.14, IC5.14, IC6.14, IC7.14, IC8.14, IC9.20, IC10.20, IC11.20, IC12.20, IC13.14, IC14.14, IC15.14, IC16.14, IC17.14, IC18.14, IC19.20, IC20.20, IC21.20, IC22.20, IC23.14, IC24.20, IC25.20, IC26.20, IC27.20, IC28.20, IC29.20, IC30.20, IC31.20, IC32.20, IC33.20, IC34.20, IC35.20, IC36.20, IC37.20, IC38.20, IC39.20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
/A0: CN2.1A, IC2.1
/A1: CN2.1B, IC2.2
/A2: CN2.1C, IC2.3
/A3: CN2.2A, IC2.5
/A4: CN2.2B, IC2.6
/C_ENB: CN2.4A, IC2.4
/D0: CN2.4B, IC9.18, IC11.18, IC19.18, IC21.18, IC24.2, IC26.2, IC32.2, IC34.2
/D1: CN2.4C, IC9.3, IC11.3, IC19.3, IC21.3, IC24.3, IC26.3, IC32.3, IC34.3
/D2: CN2.5A, IC9.16, IC11.16, IC19.16, IC21.16, IC24.4, IC26.4, IC32.4, IC34.4
/D3: CN2.5B, IC9.5, IC11.5, IC19.5, IC21.5, IC24.5, IC26.5, IC32.5, IC34.5
/D4: CN2.5C, IC9.14, IC11.14, IC19.14, IC21.14, IC24.6, IC26.6, IC32.6, IC34.6
/D5: CN2.6A, IC9.7, IC11.7, IC19.7, IC21.7, IC24.7, IC26.7, IC32.7, IC34.7
/D6: CN2.7A, IC9.12, IC11.12, IC19.12, IC21.12, IC24.8, IC26.8, IC32.8, IC34.8
/D7: CN2.7B, IC9.9, IC11.9, IC19.9, IC21.9, IC24.9, IC26.9, IC32.9, IC34.9
/D8: CN2.7C, IC10.18, IC12.18, IC20.18, IC22.18, IC25.2, IC27.2, IC33.2, IC35.2
/D9: CN2.8A, IC10.3, IC12.3, IC20.3, IC22.3, IC25.3, IC27.3, IC33.3, IC35.3
/D10: CN2.8B, IC10.16, IC12.16, IC20.16, IC22.16, IC25.4, IC27.4, IC33.4, IC35.4
/D11: CN2.8C, IC10.5, IC12.5, IC20.5, IC22.5, IC25.5, IC27.5, IC33.5, IC35.5
/D12: CN2.9A, IC10.14, IC12.14, IC20.14, IC22.14, IC25.6, IC27.6, IC33.6, IC35.6
/D13: CN2.9B, IC10.7, IC12.7, IC20.7, IC22.7, IC25.7, IC27.7, IC33.7, IC35.7
/D14: CN2.9C, IC10.12, IC12.12, IC20.12, IC22.12, IC25.8, IC27.8, IC33.8, IC35.8
/D15: CN2.10A, IC10.9, IC12.9, IC20.9, IC22.9, IC25.9, IC27.9, IC33.9, IC35.9
/PULSE_IN_01/P01: CN1.1A, IC3.1, RA1.2
/PULSE_IN_01/P02: CN1.2A, IC3.13, RA1.3
/PULSE_IN_01/P03: CN1.3A, IC3.3, RA1.4
/PULSE_IN_01/P04: CN1.4A, IC3.11, RA1.5
/PULSE_IN_01/P05: CN1.5A, IC3.5, RA1.6
/PULSE_IN_01/P06: CN1.6A, IC3.9, RA1.7
/PULSE_IN_01/P07: CN1.7A, IC4.1, RA1.8
/PULSE_IN_01/P08: CN1.8A, IC4.13, RA1.9
/PULSE_IN_01/P09: CN1.9A, IC4.3, RA3.2
/PULSE_IN_01/P10: CN1.10A, IC4.11, RA3.3
/PULSE_IN_01/P11: CN1.11A, IC4.5, RA3.4
/PULSE_IN_01/P12: CN1.12A, IC4.9, RA3.5
/PULSE_IN_01/P13: CN1.13A, IC5.1, RA3.6
/PULSE_IN_01/P14: CN1.14A, IC5.13, RA3.7
/PULSE_IN_01/P15: CN1.15A, IC5.3, RA3.8
/PULSE_IN_01/P16: CN1.16A, IC5.11, RA3.9
/PULSE_IN_01/P17: CN1.1C, IC6.1, RA2.2
/PULSE_IN_01/P18: CN1.2C, IC6.13, RA2.3
/PULSE_IN_01/P19: CN1.3C, IC6.3, RA2.4
/PULSE_IN_01/P20: CN1.4C, IC6.11, RA2.5
/PULSE_IN_01/P21: CN1.5C, IC6.5, RA2.6
/PULSE_IN_01/P22: CN1.6C, IC6.9, RA2.7
/PULSE_IN_01/P23: CN1.7C, IC7.1, RA2.8
/PULSE_IN_01/P24: CN1.8C, IC7.13, RA2.9
/PULSE_IN_01/P25: CN1.9C, IC7.3, RA4.2
/PULSE_IN_01/P26: CN1.10C, IC7.11, RA4.3
/PULSE_IN_01/P27: CN1.11C, IC7.5, RA4.4
/PULSE_IN_01/P28: CN1.12C, IC7.9, RA4.5
/PULSE_IN_01/P29: CN1.13C, IC8.1, RA4.6
/PULSE_IN_01/P30: CN1.14C, IC8.13, RA4.7
/PULSE_IN_01/P31: CN1.15C, IC8.3, RA4.8
/PULSE_IN_01/P32: CN1.16C, IC8.11, RA4.9
/PULSE_IN_01/Q01: IC3.2, IC9.2
/PULSE_IN_01/Q02: IC3.12, IC9.17
/PULSE_IN_01/Q03: IC3.4, IC9.4
/PULSE_IN_01/Q04: IC3.10, IC9.15
/PULSE_IN_01/Q05: IC3.6, IC9.6
/PULSE_IN_01/Q06: IC3.8, IC9.13
/PULSE_IN_01/Q07: IC4.2, IC9.11
/PULSE_IN_01/Q08: IC4.12, IC9.8
/PULSE_IN_01/Q09: IC4.4, IC10.2
/PULSE_IN_01/Q10: IC4.10, IC10.17
/PULSE_IN_01/Q11: IC4.6, IC10.4
/PULSE_IN_01/Q12: IC4.8, IC10.15
/PULSE_IN_01/Q13: IC5.2, IC10.6
/PULSE_IN_01/Q14: IC5.12, IC10.13
/PULSE_IN_01/Q15: IC5.4, IC10.8
/PULSE_IN_01/Q16: IC5.10, IC10.11
/PULSE_IN_01/Q17: IC6.2, IC11.2
/PULSE_IN_01/Q18: IC6.12, IC11.17
/PULSE_IN_01/Q19: IC6.4, IC11.4
/PULSE_IN_01/Q20: IC6.10, IC11.15
/PULSE_IN_01/Q21: IC6.6, IC11.6
/PULSE_IN_01/Q22: IC6.8, IC11.13
/PULSE_IN_01/Q23: IC7.2, IC11.8
/PULSE_IN_01/Q24: IC7.12, IC11.11
/PULSE_IN_01/Q25: IC7.4, IC12.2
/PULSE_IN_01/Q26: IC7.10, IC12.17
/PULSE_IN_01/Q27: IC7.6, IC12.4
/PULSE_IN_01/Q28: IC7.8, IC12.15
/PULSE_IN_01/Q29: IC8.2, IC12.6
/PULSE_IN_01/Q30: IC8.12, IC12.13
/PULSE_IN_01/Q31: IC8.4, IC12.8
/PULSE_IN_01/Q32: IC8.10, IC12.11
/PULSE_IN_02/P33: CN1.17A, IC13.1, RA5.2
/PULSE_IN_02/P34: CN1.18A, IC13.13, RA5.3
/PULSE_IN_02/P35: CN1.19A, IC13.3, RA5.4
/PULSE_IN_02/P36: CN1.20A, IC13.11, RA5.5
/PULSE_IN_02/P37: CN1.21A, IC13.5, RA5.6
/PULSE_IN_02/P38: CN1.22A, IC13.9, RA5.7
/PULSE_IN_02/P39: CN1.23A, IC14.1, RA5.8
/PULSE_IN_02/P40: CN1.24A, IC14.13, RA5.9
/PULSE_IN_02/P41: CN1.25A, IC14.3, RA7.2
/PULSE_IN_02/P42: CN1.26A, IC14.11, RA7.3
/PULSE_IN_02/P43: CN1.27A, IC14.5, RA7.4
/PULSE_IN_02/P44: CN1.28A, IC14.9, RA7.5
/PULSE_IN_02/P45: CN1.29A, IC15.1, RA7.6
/PULSE_IN_02/P46: CN1.30A, IC15.13, RA7.7
/PULSE_IN_02/P47: CN1.31A, IC15.3, RA7.8
/PULSE_IN_02/P48: CN1.32A, IC15.11, RA7.9
/PULSE_IN_02/P49: CN1.17C, IC16.1, RA6.2
/PULSE_IN_02/P50: CN1.18C, IC16.13, RA6.3
/PULSE_IN_02/P51: CN1.19C, IC16.3, RA6.4
/PULSE_IN_02/P52: CN1.20C, IC16.11, RA6.5
/PULSE_IN_02/P53: CN1.21C, IC16.5, RA6.6
/PULSE_IN_02/P54: CN1.22C, IC16.9, RA6.7
/PULSE_IN_02/P55: CN1.23C, IC17.1, RA6.8
/PULSE_IN_02/P56: CN1.24C, IC17.13, RA6.9
/PULSE_IN_02/P57: CN1.25C, IC17.3, RA8.2
/PULSE_IN_02/P58: CN1.26C, IC17.11, RA8.3
/PULSE_IN_02/P59: CN1.27C, IC17.5, RA8.4
/PULSE_IN_02/P60: CN1.28C, IC17.9, RA8.5
/PULSE_IN_02/P61: CN1.29C, IC18.1, RA8.6
/PULSE_IN_02/P62: CN1.30C, IC18.13, RA8.7
/PULSE_IN_02/P63: CN1.31C, IC18.3, RA8.8
/PULSE_IN_02/P64: CN1.32C, IC18.11, RA8.9
/PULSE_IN_02/Q33: IC13.2, IC19.2
/PULSE_IN_02/Q34: IC13.12, IC19.17
/PULSE_IN_02/Q35: IC13.4, IC19.4
/PULSE_IN_02/Q36: IC13.10, IC19.15
/PULSE_IN_02/Q37: IC13.6, IC19.6
/PULSE_IN_02/Q38: IC13.8, IC19.13
/PULSE_IN_02/Q39: IC14.2, IC19.8
/PULSE_IN_02/Q40: IC14.12, IC19.11
/PULSE_IN_02/Q41: IC14.4, IC20.2
/PULSE_IN_02/Q42: IC14.10, IC20.17
/PULSE_IN_02/Q43: IC14.6, IC20.4
/PULSE_IN_02/Q44: IC14.8, IC20.15
/PULSE_IN_02/Q45: IC15.2, IC20.6
/PULSE_IN_02/Q46: IC15.12, IC20.13
/PULSE_IN_02/Q47: IC15.4, IC20.8
/PULSE_IN_02/Q48: IC15.10, IC20.11
/PULSE_IN_02/Q49: IC16.2, IC21.2
/PULSE_IN_02/Q50: IC16.12, IC21.17
/PULSE_IN_02/Q51: IC16.4, IC21.4
/PULSE_IN_02/Q52: IC16.10, IC21.15
/PULSE_IN_02/Q53: IC16.6, IC21.6
/PULSE_IN_02/Q54: IC16.8, IC21.13
/PULSE_IN_02/Q55: IC17.2, IC21.8
/PULSE_IN_02/Q56: IC17.12, IC21.11
/PULSE_IN_02/Q57: IC17.4, IC22.2
/PULSE_IN_02/Q58: IC17.10, IC22.17
/PULSE_IN_02/Q59: IC17.6, IC22.4
/PULSE_IN_02/Q60: IC17.8, IC22.15
/PULSE_IN_02/Q61: IC18.2, IC22.6
/PULSE_IN_02/Q62: IC18.12, IC22.13
/PULSE_IN_02/Q63: IC18.4, IC22.8
/PULSE_IN_02/Q64: IC18.10, IC22.11
/PULSE_OUT_01/OUT01: IC28.18, R2.1
/PULSE_OUT_01/OUT02: IC28.17, R3.1
/PULSE_OUT_01/OUT03: IC28.16, R4.1
/PULSE_OUT_01/OUT04: IC28.15, R5.1
/PULSE_OUT_01/OUT05: IC28.14, R6.1
/PULSE_OUT_01/OUT06: IC28.13, R7.1
/PULSE_OUT_01/OUT07: IC28.12, R8.1
/PULSE_OUT_01/OUT08: IC28.11, R9.1
/PULSE_OUT_01/OUT09: IC29.18, R10.1
/PULSE_OUT_01/OUT10: IC29.17, R11.1
/PULSE_OUT_01/OUT11: IC29.16, R12.1
/PULSE_OUT_01/OUT12: IC29.15, R13.1
/PULSE_OUT_01/OUT13: IC29.14, R14.1
/PULSE_OUT_01/OUT14: IC29.13, R15.1
/PULSE_OUT_01/OUT15: IC29.12, R16.1
/PULSE_OUT_01/OUT16: IC29.11, R17.1
/PULSE_OUT_01/OUT33: IC30.18, R18.1
/PULSE_OUT_01/OUT34: IC30.17, R19.1
/PULSE_OUT_01/OUT35: IC30.16, R20.1
/PULSE_OUT_01/OUT36: IC30.15, R21.1
/PULSE_OUT_01/OUT37: IC30.14, R22.1
/PULSE_OUT_01/OUT38: IC30.13, R23.1
/PULSE_OUT_01/OUT39: IC30.12, R24.1
/PULSE_OUT_01/OUT40: IC30.11, R25.1
/PULSE_OUT_01/OUT41: IC31.18, R26.1
/PULSE_OUT_01/OUT42: IC31.17, R27.1
/PULSE_OUT_01/OUT43: IC31.16, R28.1
/PULSE_OUT_01/OUT44: IC31.15, R29.1
/PULSE_OUT_01/OUT45: IC31.14, R30.1
/PULSE_OUT_01/OUT46: IC31.13, R31.1
/PULSE_OUT_01/OUT47: IC31.12, R32.1
/PULSE_OUT_01/OUT48: IC31.11, R33.1
/PULSE_OUT_01/Q01: IC24.19, IC28.2
/PULSE_OUT_01/Q02: IC24.18, IC28.3
/PULSE_OUT_01/Q03: IC24.17, IC28.4
/PULSE_OUT_01/Q04: IC24.16, IC28.5
/PULSE_OUT_01/Q05: IC24.15, IC28.6
/PULSE_OUT_01/Q06: IC24.14, IC28.7
/PULSE_OUT_01/Q07: IC24.13, IC28.8
/PULSE_OUT_01/Q08: IC24.12, IC28.9
/PULSE_OUT_01/Q09: IC25.19, IC29.2
/PULSE_OUT_01/Q10: IC25.18, IC29.3
/PULSE_OUT_01/Q11: IC25.17, IC29.4
/PULSE_OUT_01/Q12: IC25.16, IC29.5
/PULSE_OUT_01/Q13: IC25.15, IC29.6
/PULSE_OUT_01/Q14: IC25.14, IC29.7
/PULSE_OUT_01/Q15: IC25.13, IC29.8
/PULSE_OUT_01/Q16: IC25.12, IC29.9
/PULSE_OUT_01/Q33: IC26.19, IC30.2
/PULSE_OUT_01/Q34: IC26.18, IC30.3
/PULSE_OUT_01/Q35: IC26.17, IC30.4
/PULSE_OUT_01/Q36: IC26.16, IC30.5
/PULSE_OUT_01/Q37: IC26.15, IC30.6
/PULSE_OUT_01/Q38: IC26.14, IC30.7
/PULSE_OUT_01/Q39: IC26.13, IC30.8
/PULSE_OUT_01/Q40: IC26.12, IC30.9
/PULSE_OUT_01/Q41: IC27.19, IC31.2
/PULSE_OUT_01/Q42: IC27.18, IC31.3
/PULSE_OUT_01/Q43: IC27.17, IC31.4
/PULSE_OUT_01/Q44: IC27.16, IC31.5
/PULSE_OUT_01/Q45: IC27.15, IC31.6
/PULSE_OUT_01/Q46: IC27.14, IC31.7
/PULSE_OUT_01/Q47: IC27.13, IC31.8
/PULSE_OUT_01/Q48: IC27.12, IC31.9
/PULSE_OUT_02/OUT17: IC36.18, R34.1
/PULSE_OUT_02/OUT18: IC36.17, R35.1
/PULSE_OUT_02/OUT19: IC36.16, R36.1
/PULSE_OUT_02/OUT20: IC36.15, R37.1
/PULSE_OUT_02/OUT21: IC36.14, R38.1
/PULSE_OUT_02/OUT22: IC36.13, R39.1
/PULSE_OUT_02/OUT23: IC36.12, R40.1
/PULSE_OUT_02/OUT24: IC36.11, R41.1
/PULSE_OUT_02/OUT25: IC37.18, R42.1
/PULSE_OUT_02/OUT26: IC37.17, R43.1
/PULSE_OUT_02/OUT27: IC37.16, R44.1
/PULSE_OUT_02/OUT28: IC37.15, R45.1
/PULSE_OUT_02/OUT29: IC37.14, R46.1
/PULSE_OUT_02/OUT30: IC37.13, R47.1
/PULSE_OUT_02/OUT31: IC37.12, R48.1
/PULSE_OUT_02/OUT32: IC37.11, R49.1
/PULSE_OUT_02/OUT49: IC38.18, R50.1
/PULSE_OUT_02/OUT50: IC38.17, R51.1
/PULSE_OUT_02/OUT51: IC38.16, R52.1
/PULSE_OUT_02/OUT52: IC38.15, R53.1
/PULSE_OUT_02/OUT53: IC38.14, R54.1
/PULSE_OUT_02/OUT54: IC38.13, R55.1
/PULSE_OUT_02/OUT55: IC38.12, R56.1
/PULSE_OUT_02/OUT56: IC38.11, R57.1
/PULSE_OUT_02/OUT57: IC39.18, R58.1
/PULSE_OUT_02/OUT58: IC39.17, R59.1
/PULSE_OUT_02/OUT59: IC39.16, R60.1
/PULSE_OUT_02/OUT60: IC39.15, R61.1
/PULSE_OUT_02/OUT61: IC39.14, R62.1
/PULSE_OUT_02/OUT62: IC39.13, R63.1
/PULSE_OUT_02/OUT63: IC39.12, R64.1
/PULSE_OUT_02/OUT64: IC39.11, R65.1
/PULSE_OUT_02/Q17: IC32.19, IC36.2
/PULSE_OUT_02/Q18: IC32.18, IC36.3
/PULSE_OUT_02/Q19: IC32.17, IC36.4
/PULSE_OUT_02/Q20: IC32.16, IC36.5
/PULSE_OUT_02/Q21: IC32.15, IC36.6
/PULSE_OUT_02/Q22: IC32.14, IC36.7
/PULSE_OUT_02/Q23: IC32.13, IC36.8
/PULSE_OUT_02/Q24: IC32.12, IC36.9
/PULSE_OUT_02/Q25: IC33.19, IC37.2
/PULSE_OUT_02/Q26: IC33.18, IC37.3
/PULSE_OUT_02/Q27: IC33.17, IC37.4
/PULSE_OUT_02/Q28: IC33.16, IC37.5
/PULSE_OUT_02/Q29: IC33.15, IC37.6
/PULSE_OUT_02/Q30: IC33.14, IC37.7
/PULSE_OUT_02/Q31: IC33.13, IC37.8
/PULSE_OUT_02/Q32: IC33.12, IC37.9
/PULSE_OUT_02/Q49: IC34.19, IC38.2
/PULSE_OUT_02/Q50: IC34.18, IC38.3
/PULSE_OUT_02/Q51: IC34.17, IC38.4
/PULSE_OUT_02/Q52: IC34.16, IC38.5
/PULSE_OUT_02/Q53: IC34.15, IC38.6
/PULSE_OUT_02/Q54: IC34.14, IC38.7
/PULSE_OUT_02/Q55: IC34.13, IC38.8
/PULSE_OUT_02/Q56: IC34.12, IC38.9
/PULSE_OUT_02/Q57: IC35.19, IC39.2
/PULSE_OUT_02/Q58: IC35.18, IC39.3
/PULSE_OUT_02/Q59: IC35.17, IC39.4
/PULSE_OUT_02/Q60: IC35.16, IC39.5
/PULSE_OUT_02/Q61: IC35.15, IC39.6
/PULSE_OUT_02/Q62: IC35.14, IC39.7
/PULSE_OUT_02/Q63: IC35.13, IC39.8
/PULSE_OUT_02/Q64: IC35.12, IC39.9
/RD: CN2.2C, IC1.2, IC1.5, IC1.10, IC1.13
/SEL00: IC1.3, IC9.1, IC9.19, IC10.1, IC10.19
/SEL01: IC1.6, IC11.1, IC11.19, IC12.1, IC12.19
/SEL02: IC1.8, IC19.1, IC19.19, IC20.1, IC20.19
/SEL03: IC1.11, IC21.1, IC21.19, IC22.1, IC22.19
/W00: IC23.3, IC24.11, IC25.11
/W01: IC23.6, IC32.11, IC33.11
/W02: IC23.8, IC26.11, IC27.11
/W03: IC23.11, IC34.11, IC35.11
/WR: CN2.3A, IC23.2, IC23.5, IC23.10, IC23.13
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, CN1.1B, CN1.2B, CN1.3B, CN1.4B, CN1.5B, CN1.6B, CN1.7B, CN1.8B, CN1.9B, CN1.10B, CN1.11B, CN1.12B, CN1.13B, CN1.14B, CN1.15B, CN1.16B, CN1.17B, CN1.18B, CN1.19B, CN1.20B, CN1.21B, CN1.22B, CN1.23B, CN1.24B, CN1.25B, CN1.26B, CN1.27B, CN1.28B, CN1.29B, CN1.30B, CN1.31B, CN1.32B, CN2.3B, CN2.3C, CN2.6B, CN2.6C, CN2.13A, CN2.13B, CN2.13C, CN2.14A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
unnamed: CN4.1, R2.2
unnamed: CN4.3, R3.2
unnamed: CN4.5, R4.2
unnamed: CN4.7, R5.2
unnamed: CN4.9, R6.2
unnamed: CN4.11, R7.2
unnamed: CN4.13, R8.2
unnamed: CN4.15, R9.2
unnamed: CN5.1, R10.2
unnamed: CN5.3, R11.2
unnamed: CN5.5, R12.2
unnamed: CN5.7, R13.2
unnamed: CN5.9, R14.2
unnamed: CN5.11, R15.2
unnamed: CN5.13, R16.2
unnamed: CN5.15, R17.2
unnamed: CN6.1, R18.2
unnamed: CN6.3, R19.2
unnamed: CN6.5, R20.2
unnamed: CN6.7, R21.2
unnamed: CN6.9, R22.2
unnamed: CN6.11, R23.2
unnamed: CN6.13, R24.2
unnamed: CN6.15, R25.2
unnamed: CN7.1, R26.2
unnamed: CN7.3, R27.2
unnamed: CN7.5, R28.2
unnamed: CN7.7, R29.2
unnamed: CN7.9, R30.2
unnamed: CN7.11, R31.2
unnamed: CN7.13, R32.2
unnamed: CN7.15, R33.2
unnamed: CN8.1, R34.2
unnamed: CN8.3, R35.2
unnamed: CN8.5, R36.2
unnamed: CN8.7, R37.2
unnamed: CN8.9, R38.2
unnamed: CN8.11, R39.2
unnamed: CN8.13, R40.2
unnamed: CN8.15, R41.2
unnamed: CN9.1, R42.2
unnamed: CN9.3, R43.2
unnamed: CN9.5, R44.2
unnamed: CN9.7, R45.2
unnamed: CN9.9, R46.2
unnamed: CN9.11, R47.2
unnamed: CN9.13, R48.2
unnamed: CN9.15, R49.2
unnamed: CN10.1, R50.2
unnamed: CN10.3, R51.2
unnamed: CN10.5, R52.2
unnamed: CN10.7, R53.2
unnamed: CN10.9, R54.2
unnamed: CN10.11, R55.2
unnamed: CN10.13, R56.2
unnamed: CN10.15, R57.2
unnamed: CN11.1, R58.2
unnamed: CN11.3, R59.2
unnamed: CN11.5, R60.2
unnamed: CN11.7, R61.2
unnamed: CN11.9, R62.2
unnamed: CN11.11, R63.2
unnamed: CN11.13, R64.2
unnamed: CN11.15, R65.2
unnamed: IC1.1, IC2.11, IC23.1
unnamed: IC1.4, IC2.10, IC23.4
unnamed: IC1.9, IC2.9, IC23.9
unnamed: IC1.12, IC2.7, IC23.12
unnamed: LED1.1, R1.2
VDD: CN2.15A, CN2.15B, CN2.15C, CN2.16A, CN2.16B, CN2.16C, CN3.1, FL1.1
